<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfsk_modulator</value></param>
<param><key>category</key><value>[Custom]/Modulation</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GFSK Modulator</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>BT</value></param>
<param><key>label</key><value>Bandwidth-Time Product</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>custom_rect_encoder_bf</key>
<param><key>id</key><value>custom_rect_encoder_bf_0</value></param>
<param><key>samples_per_symbol</key><value>samples_per_symbol</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>label</key><value>Number of Filter Taps</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>fm_modulator</key>
<param><key>id</key><value>fm_modulator_0</value></param>
<param><key>modulation_sensitivity</key><value>modulation_sensitivity</value></param>
<param><key>samp_rate</key><value>symbol_rate*samples_per_symbol</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>firdes.gaussian(1, samples_per_symbol/4, BT, filter_taps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>modulation_sensitivity</value></param>
<param><key>label</key><value>Modulation Sensitivity</value></param>
<param><key>value</key><value>4e3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>label</key><value>Symbol Rate</value></param>
<param><key>value</key><value>1.2e3</value></param>
</block>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>custom_rect_encoder_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>custom_rect_encoder_bf_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_modulator_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>fm_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
