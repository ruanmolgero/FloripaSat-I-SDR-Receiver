<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_modulator</value></param>
<param><key>category</key><value>[Custom]/Modulation</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>FM Modulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_FM</value></param>
<param><key>value</key><value>2*pi*modulation_sensitivity / samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>numpy.pi</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_magphase_to_complex</key>
<param><key>id</key><value>blocks_magphase_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>gain_FM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>custom_circular_accumulator_ff</key>
<param><key>id</key><value>custom_circular_accumulator_ff_0</value></param>
<param><key>modulus</key><value>2*pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>modulation_sensitivity</value></param>
<param><key>label</key><value>Modulation Sensitivity</value></param>
<param><key>value</key><value>30e3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_magphase_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_magphase_to_complex_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>custom_circular_accumulator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>custom_circular_accumulator_ff_0</source_block_id><sink_block_id>blocks_magphase_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
