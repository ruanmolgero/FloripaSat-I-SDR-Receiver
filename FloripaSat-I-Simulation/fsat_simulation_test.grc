<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsat_simulation_test</value></param>
<param><key>author</key><value>Rafael Alevato &amp;&amp; Ruan Lopes</value></param>
<param><key>description</key><value>Radio simulation test for the FloripaSat-I CubeSat</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FloripaSat-I Simulation Test</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_shift</value></param>
<param><key>value</key><value>1e3</value></param>
<param><key>gui_hint</key><value>tabs@1 : 0,0,1,1</value></param>
<param><key>label</key><value>"Channel Frequency Shift"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation_sensitivity</value></param>
<param><key>value</key><value>4e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>value</key><value>1e-6</value></param>
<param><key>gui_hint</key><value>tabs@1 : 2,0,1,1</value></param>
<param><key>label</key><value>"Channel Noise Amplitude"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e-6</value></param>
<param><key>step</key><value>1e-6</value></param>
<param><key>stop</key><value>0.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_shift</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@1 : 1,0,1,1</value></param>
<param><key>label</key><value>"Channel Phase Shift"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>2*pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>numpy.pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(40), 0.35, 45*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>symbol_rate*samples_per_symbol</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate_rx</value></param>
<param><key>value</key><value>sample_rate_tx*6/5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate_tx</value></param>
<param><key>value</key><value>symbol_rate*samples_per_symbol*25/6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>1.2e3</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/rpa/code/FloripaSat-I-SDR-Receiver/Binary-Files/fsat-hello.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>custom_frame_sync_bb</key>
<param><key>id</key><value>custom_frame_sync_bb_0</value></param>
<param><key>bytes_message_size</key><value>3</value></param>
<param><key>threshold</key><value>32</value></param>
<param><key>sync_word</key><value>[0,1,0,1,1,1,0,1,1,1,1,0,0,1,1,0,0,0,1,0,1,0,1,0,0,1,1,1,1,1,1,0]</value></param>
</block>
<block>
<key>custom_rect_encoder_bf</key>
<param><key>id</key><value>custom_rect_encoder_bf_0</value></param>
<param><key>samples_per_symbol</key><value>samples_per_symbol</value></param>
</block>
<block>
<key>custom_symbol_sync_early_late_fb</key>
<param><key>id</key><value>custom_symbol_sync_early_late_fb_0</value></param>
<param><key>bandwidth</key><value>0.01*sample_rate</value></param>
<param><key>damping_ratio</key><value>0.707</value></param>
<param><key>loop_gain</key><value>3.22</value></param>
<param><key>sample_period</key><value>1/sample_rate</value></param>
<param><key>samples_per_symbol</key><value>samples_per_symbol</value></param>
</block>
<block>
<key>custom_symbol_sync_gardner_fb</key>
<param><key>id</key><value>custom_symbol_sync_gardner_fb_0</value></param>
<param><key>bandwidth</key><value>0.01*sample_rate</value></param>
<param><key>damping_ratio</key><value>0.707</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>loop_gain</key><value>3.22</value></param>
<param><key>sample_period</key><value>1/sample_rate</value></param>
<param><key>samples_per_symbol</key><value>samples_per_symbol</value></param>
</block>
<block>
<key>fm_demodulator</key>
<param><key>id</key><value>fm_demodulator_0</value></param>
<param><key>modulation_sensitivity</key><value>modulation_sensitivity</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
</block>
<block>
<key>fm_modulator</key>
<param><key>id</key><value>fm_modulator_0</value></param>
<param><key>modulation_sensitivity</key><value>modulation_sensitivity</value></param>
<param><key>samp_rate</key><value>symbol_rate*samples_per_symbol</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>firdes.gaussian(1, samples_per_symbol/2, 0.25, 100)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>symbol_rate*samples_per_symbol</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>tabs@0 : 2,0,1,1</value></param>
<param><key>name</key><value>"Demodulated Signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-180</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>tabs@0 : 0,0,1,1</value></param>
<param><key>name</key><value>"Transmitted Signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-180</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>tabs@0 : 1,0,1,1</value></param>
<param><key>name</key><value>"Received Signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-180</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>tabs@1 : 10,0,7,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>name</key><value>"Message"</value></param>
<param><key>size</key><value>280</value></param>
<param><key>srate</key><value>symbol_rate*samples_per_symbol</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-1.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>tabs@1 : 3,0,7,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Transmitted"</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"Received"</value></param>
<param><key>name</key><value>"Signal"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>11200</value></param>
<param><key>srate</key><value>symbol_rate*samples_per_symbol</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-1.2</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>6</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>25</value></param>
<param><key>taps</key><value>firdes.low_pass(25, 1, 0.5/25, 0.001)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0_0_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value>firdes.low_pass(6,1,0.5/6,0.001)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0_0_1_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass(1,1,0.5/5,0.001)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>simple_channel</key>
<param><key>id</key><value>simple_channel_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>freq_shift</key><value>freq_shift</value></param>
<param><key>noise_amplitude</key><value>noise_amp</value></param>
<param><key>noise_seed</key><value>1</value></param>
<param><key>phase_shift</key><value>phase_shift</value></param>
<param><key>samp_rate</key><value>sample_rate_tx</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>label1</key><value>Time</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>custom_rect_encoder_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>custom_frame_sync_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>custom_rect_encoder_bf_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>custom_symbol_sync_early_late_fb_0</source_block_id><sink_block_id>custom_frame_sync_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>custom_symbol_sync_gardner_fb_0</source_block_id><sink_block_id>custom_frame_sync_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_demodulator_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_modulator_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>fm_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>simple_channel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0_0</source_block_id><sink_block_id>fm_demodulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0_1_0</source_block_id><sink_block_id>custom_symbol_sync_early_late_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0_1_0</source_block_id><sink_block_id>custom_symbol_sync_gardner_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>simple_channel_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
